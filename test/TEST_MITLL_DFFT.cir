* Generated by Xic from cell TEST_MITLL_DFFT
********************* MAIN CIRCUIT ***************************
.tran 0.5p 300p 0 0.25p UIC
I0 0 10 pulse(0 600u 1p 2p 2p 1p 50p)
X0 10 1 MITLL_DCSFQ
X1 1 2 MITLL_PTLTX
T1 2 0 3 0 Z0=5 td=10p
I1 0 11 pwl( 0 0 50p 0 53p 600u 56p 0 200p 0 203p 600u 206p 0)
X2 11 8 MITLL_DCSFQ
X3 8 9 MITLL_PTLTX
T2 9 0 4 0 Z0=5 td=10p
X4 4 3 5 MITLL_DFFT
T3 5 0 6 0 Z0=5 Td=10p
X5 6 7 MITLL_PTLRX
R0 7 0 2

******************** MITLL_PTLRX ******************************
.subckt MITLL_PTLRX IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends MITLL_PTLRX

*********************** MITLL_DCSFQ ****************************
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ

*********************** MITLL_PTLTX *****************************
.subckt MITLL_PTLTX IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends MITLL_PTLTX

************************ MITLL_DFFT *****************************
.subckt MITLL_DFFT IN CLK OUT
.include MITLL_DFFT_models.inc
.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0
.param B01rx1=0.7938328024901055*Scaling
.param B01rx2=0.9061035220612258*Scaling
.param B01tx1=3.027086604268269*Scaling
.param B02rx2=0.9637658214414866*Scaling
.param B1=1.4277751453682372*Scaling
.param B2=1.4987454889402436*Scaling
.param B3=0.9602271459863292*Scaling
.param B4=1.6952020313450789*Scaling
.param B5=1.1734522448720066*Scaling
.param B6=1.3640447384085008*Scaling
.param B7=1.4999656477674999*Scaling
.param IB01rx1=0.00011545625675287277*Scaling
.param IB01rx2=0.00010188913593562593*Scaling
.param IB01tx1=0.00018140292212037875*Scaling
.param IB1=0.00012040154933150344*Scaling
.param IB2=6.347858159093747e-05*Scaling
.param IB3=0.00015363347549359588*Scaling
.param IB4=0.0001617296221156164*Scaling
.param L01rx1=1.4066532862604666e-12*(1/Scaling-(1-Scaling))
.param L01rx2=1.2310168079514995e-12*(1/Scaling-(1-Scaling))
.param L02rx1=3.2946658347639157e-12*(1/Scaling-(1-Scaling))
.param L02rx2=2.4403564820406232e-12*(1/Scaling-(1-Scaling))
.param L02tx1=1.804008602901138e-12*(1/Scaling-(1-Scaling))
.param L03rx2=3.649437369463691e-12*(1/Scaling-(1-Scaling))
.param L1=1.1284513693561857e-12*(1/Scaling-(1-Scaling))
.param L2a=5.40282982300358e-13*(1/Scaling-(1-Scaling))
.param L2b=1.6028916111527104e-12*(1/Scaling-(1-Scaling))
.param L3=9.453744039701024e-13*(1/Scaling-(1-Scaling))
.param L3a=1.1141430616098756e-12*(1/Scaling-(1-Scaling))
.param L4=4.44008649731592e-12*(1/Scaling-(1-Scaling))
.param L5a=3.6349389291208616e-12*(1/Scaling-(1-Scaling))
.param L5b=5.939354402373924e-13*(1/Scaling-(1-Scaling))
.param L6=1.323271380268522e-12*(1/Scaling-(1-Scaling))
.param L7=1.907903028464016e-12*(1/Scaling-(1-Scaling))
.param L8=1.7976360392814265e-12*(1/Scaling-(1-Scaling))
.param LRB01rx1=5e-13/Scaling
.param LRB01rx2=5e-13/Scaling
.param LRB01tx1=1e-12/Scaling
.param LRB02rx2=1e-12/Scaling
.param LRB1=1e-12/Scaling
.param LRB2=1e-12/Scaling
.param LRB3=1e-12/Scaling
.param LRB4=1e-12/Scaling
.param LRB5=1e-12/Scaling
.param LRB6=1e-12/Scaling
.param LRB7=1e-12/Scaling
.param R01rx2=B0Rs/B01rx2
.param RB01rx1=B0Rs/B01rx1
.param RB01tx1=B0Rs/B01tx1
.param RB02rx2=B0Rs/B02rx2
.param RB1=B0Rs/B1
.param RB2=B0Rs/B2
.param RB3=B0Rs/B3
.param RB4=B0Rs/B4
.param RB5=B0Rs/B5
.param RB6=B0Rs/B6
.param RB7=B0Rs/B7
B01rx1 10 32 54 jmitll area=B01rx1
B01rx2 4 18 49 jmitll area=B01rx2
B01tx1 15 47 59 jmitll area=B01tx1
B02rx2 5 21 50 jmitll area=B02rx2
B1 11 35 55 jmitll area=B1
B2 8 9 53 jmitll area=B2
B3 12 38 56 jmitll area=B3
B4 13 41 57 jmitll area=B4
B5 7 13 52 jmitll area=B5
B6 6 24 51 jmitll area=B6
B7 14 44 58 jmitll area=B7
IB01rx1 0 34 pwl(0 0 5p IB01rx1)
IB01rx2 0 20 pwl(0 0 5p IB01rx2)
IB01tx1 0 46 pwl(0 0 5p IB01tx1)
IB1 0 37 pwl(0 0 5p IB1)
IB2 0 40 pwl(0 0 5p IB2)
IB3 0 43 pwl(0 0 5p IB3)
IB4 0 23 pwl(0 0 5p IB4)
L01rx1 IN 10 L01rx1
L01rx2 CLK 4 L01rx2
L02rx1 10 27 L02rx1
L02rx2 4 16 L02rx2
L02tx1 15 31 L02tx1
L03rx2 16 5 L03rx2
L1 27 11 L1
L2a 11 28 L2a
L2b 28 8 L2b
L3 12 29 L3
L3a 9 12 L3a
L4 29 13 L4
L5a 13 30 L5a
L5b 30 14 L5b
L6 14 15 L6
L7 6 7 L7
L8 5 6 L8
LIB01tx1 15 46 0.2p
LIB2 29 40 0.2p
LIB3 30 43 0.2p
LP01rx1 32 0 0.34p
LP01rx2 18 0 0.34p
LP01tx1 47 0 5e-14
LP02rx2 21 0 0.06p
LP1 35 0 0.2p
LP3 38 0 0.2p
LP4 41 0 0.2p
LP6 24 0 0.2p
LPB7 44 0 0.2p
LPIB1 28 37 0.2p
LPIB4 6 23 0.2p
LPR01rx1 27 34 0.2p
LPR01rx2 16 20 2e-13
LRB01rx1 33 0 LRB01rx1
LRB01rx2 19 0 LRB01rx2
LRB01tx1 48 0 LRB01tx1
LRB02rx2 22 0 LRB02rx2
LRB1 36 0 LRB1
LRB2 26 9 LRB2
LRB3 39 0 LRB3
LRB4 42 0 LRB4
LRB5 25 13 LRB5
LRB6 17 0 LRB6
LRB7 45 0 LRB7
R01rx2 4 19 R01rx2
RB01rx1 10 33 RB01rx1
RB01tx1 15 48 RB01tx1
RB02rx2 5 22 RB02rx2
RB1 11 36 RB1
RB2 8 26 RB2
RB3 12 39 RB3
RB4 13 42 RB4
RB5 7 25 RB5
RB6 6 17 RB6
RB7 14 45 RB7
RINStx1 31 OUT 1.36
.ends MITLL_DFFT

*********************** CONTROLS ***************************************
.model jmitll jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* Nb 4500 A/cm2
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

*.save @IB01rx2.X0[c]
*.save @IB4.X0[c]
*.save @IB01rx1.X0[c]
*.save @IB1.X0[c]
*.save @IB01tx1.X0[c]
*.save @IB3.X0[c]
*.save @IB2.X0[c]
*.save @I0.X3[c]
*.save @I0.X2[c]
*.save @I1.X2[c]
*.save @I0.X5[c]
*.save @I1.X5[c]
*.save @I0.X1[c]
*.save @I1.X1[c]
*.save @I0.X4[c]
*.save @I1.X4[c]
*.save @I0[c]
*.save @I1[c]
.plot v(10) v(1) v(2) v(3) v(11) v(8) v(9) v(4) v(5) v(6) v(7)
