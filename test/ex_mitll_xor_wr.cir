* Generated by Xic from cell TEST_MITLL_XORT
* Author: Lieze Schindler
.tran 0.25p 600p 0 0.25p UIC
I0 0 1 pulse(0 600u 1p 2p 2p 1p 20p)
I1 0 5 pwl(0 0 30p 0 33p 600u 36p 0 166p 0 169p 600u 172p 0 185p 0 188p 600u
+ 191p 0)
I2 0 13 pwl(0 0 30p 0 33p 600u 36p 0 125p 0 128p 600u 131p 0 190p 0 193p 600u
+ 196p 0)
R0 11 0 2
T1 3 0 4 0 Z0=5 Td=10pS
T2 7 0 8 0 Z0=5 Td=10pS
T3 15 0 12 0 Z0=5 Td=10pS
T4 9 0 10 0 Z0=5 Td=10pS
X0 4 8 12 9 LSmitll_XORT
X1 1 2 LSmitll_DCSFQ
X2 2 3 LSmitll_ptltx
X3 5 6 LSmitll_DCSFQ
X4 6 7 LSmitll_ptltx
X5 10 11 LSmitll_ptlrx
X6 13 14 LSmitll_DCSFQ
X7 14 15 LSmitll_ptltx
.subckt LSmitll_XORT IN_CLK IN_1 IN_2 OUT
.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0
.param Rsheet=2
.param Lsheet=1.13e-12
.param B01=2.7983490538350515*Scaling
.param B01rx1=1.212437539306743*Scaling
.param B01rx3=0.723632051793937*Scaling
.param B02rx1=1.158563397869644*Scaling
.param B02rx3=0.7720405171362006*Scaling
.param B02tx1=1.3694614271852381*Scaling
.param B03=1.9158496762185455*Scaling
.param B03rx1=0.8977497804392051*Scaling
.param B03rx3=0.8279924677726137*Scaling
.param B07=1.485660096042623*Scaling
.param B08=0.9336027575165575*Scaling
.param B09=1.285905326821399*Scaling
.param B10=1.6862960210069688*Scaling
.param IB01=8.921799237355735e-05*Scaling
.param IB01rx1=0.00022978945326287327*Scaling
.param IB01rx3=0.00013185773657978396*Scaling
.param IB02tx1=6.645679600882128e-05*Scaling
.param IB04=0.0001340456594104776*Scaling
.param IB05=0.00017762890401107424*Scaling
.param L01rx1=1.8603745800181836e-12*(1/Scaling-(1-Scaling))
.param L01rx3=1.8927662194191664e-12*(1/Scaling-(1-Scaling))
.param L02rx1=2.1528545443650416e-12*(1/Scaling-(1-Scaling))
.param L02rx3=2.2380595538965777e-12*(1/Scaling-(1-Scaling))
.param L03=2.2792556185351873e-12*(1/Scaling-(1-Scaling))
.param L03rx1=1.9728813390683723e-12*(1/Scaling-(1-Scaling))
.param L03rx3=2.0204747723552323e-12*(1/Scaling-(1-Scaling))
.param L03tx1=2.2260825655975414e-12*(1/Scaling-(1-Scaling))
.param L04rx1=2.396600763858905e-12*(1/Scaling-(1-Scaling))
.param L04rx3=2.017773718070878e-12*(1/Scaling-(1-Scaling))
.param L08=1.7515381267998072e-12*(1/Scaling-(1-Scaling))
.param L09=1.2619922936879474e-12*(1/Scaling-(1-Scaling))
.param L10=2.2246248392778723e-12*(1/Scaling-(1-Scaling))
.param L11=1.803328457164782e-12*(1/Scaling-(1-Scaling))
.param L12=3.8657981705766425e-12*(1/Scaling-(1-Scaling))
.param L14=1.635403210771492e-12*(1/Scaling-(1-Scaling))
.param LRB01=(RB01/Rsheet)*Lsheet
.param LRB01rx1=(RB01rx1/Rsheet)*Lsheet
.param LRB01rx3=(RB01rx3/Rsheet)*Lsheet
.param LRB02rx1=(RB02rx1/Rsheet)*Lsheet
.param LRB02rx3=(RB02rx3/Rsheet)*Lsheet
.param LRB02tx1=(RB02tx1/Rsheet)*Lsheet
.param LRB03=(RB03/Rsheet)*Lsheet
.param LRB03rx1=(RB03rx1/Rsheet)*Lsheet
.param LRB03rx3=(RB03rx3/Rsheet)*Lsheet
.param LRB07=(RB07/Rsheet)*Lsheet
.param LRB08=(RB08/Rsheet)*Lsheet
.param LRB09=(RB09/Rsheet)*Lsheet
.param LRB10=(RB10/Rsheet)*Lsheet
.param RB01=B0Rs/B01
.param RB01rx1=B0Rs/B01rx1
.param RB01rx3=B0Rs/B01rx3
.param RB02rx1=B0Rs/B02rx1
.param RB02rx3=B0Rs/B02rx3
.param RB02tx1=B0Rs/B02tx1
.param RB03=B0Rs/B03
.param RB03rx1=B0Rs/B03rx1
.param RB03rx3=B0Rs/B03rx3
.param RB07=B0Rs/B07
.param RB08=B0Rs/B08
.param RB09=B0Rs/B09
.param RB10=B0Rs/B10
B01 10 49 78 jmitll area=B01
B01RX1 12 43 75 jmitll area=B01rx1
B01RX2 22 61 83 jmitll area=B01rx1
B01RX3 7 29 70 jmitll area=B01rx3
B02RX1 13 45 76 jmitll area=B02rx1
B02RX2 23 63 84 jmitll area=B02rx1
B02RX3 8 31 71 jmitll area=B02rx3
B02TX1 19 57 81 jmitll area=B02tx1
B03 10 11 74 jmitll area=B03
B03RX1 14 47 77 jmitll area=B03rx1
B03RX2 24 65 85 jmitll area=B03rx1
B03RX3 9 33 72 jmitll area=B03rx3
B04 20 67 86 jmitll area=B01
B06 20 21 82 jmitll area=B03
B07 16 17 79 jmitll area=B07
B08 18 55 80 jmitll area=B08
B09 5 6 69 jmitll area=B09
B10 5 35 73 jmitll area=B10
IB01 0 38 pwl(0 0 5p IB01)
IB01RX1 0 37 pwl(0 0 5p IB01rx1)
IB01RX2 0 53 pwl(0 0 5p IB01rx1)
IB01RX3 0 25 pwl(0 0 5p IB01rx3)
IB02 0 54 pwl(0 0 5p IB01)
IB02TX1 0 42 pwl(0 0 5p IB02tx1)
IB04 0 41 pwl(0 0 5p IB04)
IB05 0 26 pwl(0 0 5p IB05)
L01RX1 IN_1 12 L01rx1
L01RX2 IN_2 22 L01rx1
L01RX3 IN_CLK 7 L01rx3
L02RX1 12 39 L02rx1
L02RX2 22 59 L02rx1
L02RX3 7 27 L02rx3
L03 11 15 L03
L03RX1 39 13 L03rx1
L03RX2 59 23 L03rx1
L03RX3 27 8 L03rx3
L03TX1 19 52 L03tx1
L04RX1 13 14 L04rx1
L04RX2 23 24 L04rx1
L04RX3 8 9 L04rx3
L06 15 21 L03
L08 15 16 L08
L09 17 18 L09
L10 6 18 L10
L11 9 5 L11
L12 18 19 L12
L14 14 10 L14
L15 24 20 L14
LP01 49 0 2e-13
LP01RX1 43 0 2e-13
LP01RX2 61 0 2e-13
LP01RX3 29 0 2e-13
LP02RX1 45 0 2e-13
LP02RX2 63 0 2e-13
LP02RX3 31 0 2e-13
LP02TX1 57 0 2e-13
LP03 67 0 2e-13
LP03RX1 47 0 2e-13
LP03RX2 65 0 2e-13
LP03RX3 33 0 2e-13
LP05 55 0 2e-13
LP10 35 0 2e-13
LPR01 38 10 2e-13
LPR01RX1 37 39 2e-13
LPR01RX2 53 59 2e-13
LPR01RX3 25 27 2e-13
LPR02 54 20 2e-13
LPR02TX1 42 19 2e-13
LPR04 41 15 2e-13
LPR05 26 5 2e-13
LRB01 50 0 LRB01
LRB01RX1 44 0 LRB01rx1
LRB01RX2 62 0 LRB01rx1
LRB01RX3 30 0 LRB01rx3
LRB02RX1 46 0 LRB02rx1
LRB02RX2 64 0 LRB02rx1
LRB02RX3 32 0 LRB02rx3
LRB02TX1 58 0 LRB02tx1
LRB03 40 11 LRB03
LRB03RX1 48 0 LRB03rx1
LRB03RX2 66 0 LRB03rx1
LRB03RX3 34 0 LRB03rx3
LRB04 68 0 LRB01
LRB06 60 21 LRB03
LRB07 51 17 LRB07
LRB08 56 0 LRB08
LRB09 28 6 LRB09
LRB10 36 0 LRB10
RB01 10 50 RB01
RB01RX1 12 44 RB01rx1
RB01RX2 22 62 RB01rx1
RB01RX3 7 30 RB01rx3
RB02RX1 13 46 RB02rx1
RB02RX2 23 64 RB02rx1
RB02RX3 8 32 RB02rx3
RB02TX1 19 58 RB02tx1
RB03 10 40 RB03
RB03RX1 14 48 RB03rx1
RB03RX2 24 66 RB03rx1
RB03RX3 9 34 RB03rx3
RB04 20 68 RB01
RB06 20 60 RB03
RB07 16 51 RB07
RB08 18 56 RB08
RB09 5 28 RB09
RB10 5 36 RB10
RINSTX1 52 OUT 1.36
.ends LSmitll_XORT
.subckt LSmitll_ptltx IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends LSmitll_ptltx
.subckt LSmitll_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends LSmitll_DCSFQ
.subckt LSmitll_ptlrx IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends LSmitll_ptlrx
.model jjmit jj(rtype=1, vg=2.6mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* Nb 30 A/cm2
.model jmitll jj(rtype=1, vg=2.6mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)
.plot v(4) v(8) v(12) V(9)
